# IAR project STM8S-freemodbus.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\APP\; ..\modbus\include\; ..\modbus\rtu\; ..\modbus\port_STM8s\
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    ../APP/: main.c
  group modbus
    ../modbus/: mb.c
    ../modbus/include/: mbconfig.h
    ../modbus/rtu/: mbcrc.c mbrtu.c
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group modbus-STM8s-port
    ../modbus/port_STM8s/: port.h portevent.c portserial.c porttimer.c
